# Keil uVision project INVERTER.uvprojx, settings and files
target BAT32G139GH48 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G139GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G139.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMS_BAT139_INV +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\code\head\4_powerlib_h;..\code\head\1_driver_h;..\code\head\2_app_h;..\code\head\3_user_h
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000200 size 0x8000
  scatter file: .\Objects\CMS_BAT139_INV.sct
  group driver_s
    ../code/source/1_driver_s/: adc.c adc_user.c can.c can_user.c clk.c cmp.c cmp_user.c dac.c div.c dma.c elc.c flash.c flash_user.c gpio.c iica.c iica_user.c intp.c intp_user.c key.c key_user.c pcbz.c pga.c retarget.c rst.c rtc.c rtc_user.c sci.c sci_user.c tim4.c tim4_user.c tim8.c tim8_user.c tima.c tima_user.c timb.c timb_user.c timc.c timc_user.c timm.c timm_user.c wdt.c wdt_user.c
  group driver_h
    ../code/head/1_driver_h/: adc.h clk.h cmp.h dac.h div.h dma.h elc.h flash.h gpio.h pcbz.h pga.h rst.h rtc.h tim4.h tima.h timb.h timc.h timm.h userdefine.h wdt.h intp.h sci.h
  group user_s
    ../code/source/3_user_s/: main.c interrupt.c sys_struct.c sys_variable_init.c sys_hardware_init.c sys_state_machine.c user_parallel.c user_sample.c user_function.c user_sine_table.c user_fault_check.c user_communication.c change.c
  group user_h
    ../code/head/3_user_h/: sys_struct.h sys_mcu_header.h sys_hardware_init.h sys_define_config.h sys_define_param.h sys_state_machine.h user_parallel.h user_sample.h user_function.h user_communication.h
  group powerlib_s
    ../code/source/4_powerlib_s/: INV_ctrl.c PID_ctrl.c repeat_ctrl.c PQ_droop_ctrl.c PFC_ctrl.c PLL_ctrl.c
  group powerlib_h
    ../code/head/4_powerlib_h/: INV_ctrl.h PID_ctrl.h repeat_ctrl.h PQ_Droop_Ctrl.h PFC_ctrl.h PLL_ctrl.h
  group doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
